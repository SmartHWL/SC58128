# Keil uVision project SL58128_MiniSys.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SC32F58128 SILAN
  pack: Keil.SC32F58xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: GeneralMotorCtrl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c misc: --diag_suppress=1 --diag_suppress=177 --diag_suppress=550
  c include: .\include\drive\BSP;.\include\drive\M0DRV;.\include\drive\HAL;.\include\lib;.\include\pfc;.\include\user;.\include\lib\math_blocks\v4.0;.\include\drive\HAL;.\include\motorLib;.\include\Hisense_Leovel0_include\common;.\HARDWARE\IIS2DLPC;.\MODBUS\Freemodbus\modbus\ascii;.\MODBUS\Freemodbus\modbus\functions;.\MODBUS\Freemodbus\modbus\include;.\MODBUS\Freemodbus\modbus\rtu;.\MODBUS\Freemodbus\modbus\tcp;.\MODBUS\Freemodbus\port;.\MODBUS\Freemodbus\modbus
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Objects\GeneralMotorCtrlFix.sct
  group user
    ./source/User/: SL_niv.c SL_main.c UserMath.c UserModbus.c
  group UI_Lib
    ./source/lib/: OSC.lib
  group driver/BSP
    ./source/drive/BSP/: devInit.c BSP_gpio.c BSP_dma.c BSP_uart.c BSP_iic.c BSP_pwm.c
  group CommonLib
    ./source/drive/HAL/: timer4Tick.c
  group HARDWARE
    ./HARDWARE/IIS2DLPC/: iis2dlpc_reg.c
  group FreeModbus
    ./MODBUS/Freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./MODBUS/Freemodbus/modbus/ascii/: mbascii.c
    ./MODBUS/Freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./MODBUS/Freemodbus/modbus/tcp/: mbtcp.c
    ./MODBUS/Freemodbus/modbus/: mb.c
  group Port
    ./MODBUS/Freemodbus/port/: portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 5.3.0, Device:Driver:CAN 1.0.0, Device:Driver:DMA 1.0.0, Device:Driver:GPIO 1.0.0, Device:Driver:IIC 1.0.0, Device:Driver:PWM 1.0.0, Device:Driver:QEP 1.0.0, Device:Driver:SPI 1.0.0, Device:Driver:SystemClock 1.0.0, Device:Driver:TIMER 1.0.0, Device:Driver:UART 1.0.0, Device:Startup 1.0.0
